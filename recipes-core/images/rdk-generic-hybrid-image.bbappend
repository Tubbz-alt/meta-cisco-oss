#
# Add Cisco packages to the hybrid RDK image
#
#
IMAGE_INSTALL +="packagegroup-cisco-packages"

