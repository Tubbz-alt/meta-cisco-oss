EXTRA_OECONF = " --enable-lgpl"
