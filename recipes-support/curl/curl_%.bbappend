DEPENDS = "c-ares"
EXTRA_OECONF = "--enable-ares"
